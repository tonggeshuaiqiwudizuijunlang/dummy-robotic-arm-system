# Keil uVision project FSP_Project.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.6.3.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ  FPU3(SFPU)  CLOCK(12000000) ELITTLE
  output: FSP_Project +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=6
  c misc: @./via/rasc_armclang.via
  c include: ..\keil_test;.\ra;.\ra_cfg;.\ra_gen;.\bsp;.\bsp\dwt;.\bsp\can;.\bsp\uart;.\bsp\gpio;.\bsp\usb;.\modules;.\modules\daemon;.\modules\controller;.\modules\step_motor;.\modules\wifi;.\modules\bluetooth;.\modules\message_center;.\modules\dummy_kinematic;.\modules\bluetooth;.\modules\vision;.\modules\remote;.\modules\serial_debug;.\application;.\src
  asm misc: --via=./via/rasc_armasm.via
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_warmstart.c robot_task_entry.c daemon_task_entry.c motor_ctrl_task_entry.c
  group bsp
    ./bsp/can/: bsp_can.c bsp_can.h
    ./bsp/gpio/: bsp_gpio.c bsp_gpio.h
    ./bsp/uart/: bsp_uart.c bsp_uart.h
    ./bsp/dwt/: bsp_dwt.c bsp_dwt.h
    ./bsp/usb/: bsp_usb.c bsp_usb.h r_usb_pcdc_descriptor.c
  group modules
    ./modules/controller/: controller.c controller.h
    ./modules/step_motor/: step_motor.c step_motor.h
    ./modules/daemon/: daemon.c daemon.h
    ./modules/: motor_def.h robot_types.h
    ./modules/message_center/: message_center.c message_center.h
    ./modules/remote/: flysky.c flysky.h
    ./modules/dummy_kinematic/: dummy_kinematic_v2.c dummy_kinematic_v2.h
    ./modules/vision/: vision.c vision.h
    ./modules/wifi/: wifi.c wifi.h
    ./modules/bluetooth/: bluetooth.c bluetooth.h
    ./modules/serial_debug/: serial_debug.c serial_debug.h
  group application
    ./application/: dummy_cmd.c dummy_cmd.h dummy_motormatic.c dummy_motormatic.h dummy_workspace_notes.md
software components: Flex Software:RA Configuration 1.0.0
